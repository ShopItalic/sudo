# Keil uVision project bc_ring_app.uvprojx, settings and files
target flash_s140_nrf52_7.2.0_softdevice (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: s140_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\config
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002260 size 0x3dda0
  memory RVCT10: RAM 0x800000 size 0x10000
  link misc: --diag_suppress 6330
  group user
    ../../user/src/: main.c test.c user.c
    ../../user/inc/: FreeRTOSConfig.h user_rtos_config.h sdk_config.h
    ../../../../bc_ros/bc_config/: ring_config.h customer.h
  group app
    ../../../../bc_ros/bc_application/: app.c app_ppg_handler.c app_package.c app_rtc_handler.c app_ble_handler.c app_pmic_handler.c app_ppg_data_handler.c app_g_sensor_handler.c app_model_handler.c app_cmd_handler.c app_sleep_handler.c app_temper_handler.c app_hardware_check.c app_ppg_file_data_handler.c app_key_handler.c app_linear_motor_handler.c app_touch_button_handler.c app_pdm_handler.c app_ble_speed_handler.c app_tsdb_handler.c app_hardline_tsdb_handler.c app_opus.c app_six_axis_sensor_handler.c
  group bc_moudle
    ../../../../bc_ros/bc_module/: bc_module.c
    ../../../../bc_ros/bc_module/device_info/: bc_device_info.c
    ../../../../bc_ros/bc_module/strategy_value/: bc_strategy_value.c
    ../../../../bc_ros/bc_module/bc_ldo_switch/: bc_ldo_switch.c
    ../../../../bc_ros/bc_module/rtc/: bc_rtc.c
    ../../../../bc_ros/bc_module/i2c_bus/: bc_device_i2c_bus_handler.c
    ../../../../bc_ros/bc_module/wtd/: bc_watchdog.c
    ../../../../bc_ros/bc_module/motor/: bc_linear_motor.c
    ../../../../bc_ros/bc_module/pdm/: bc_pdm.c
    ../../../../bc_ros/bc_module/timer/: bc_timer.c
  group bc_module/pmic
    ../../../../bc_ros/bc_module/pmic/: bc_pmic.c bc_power.c bc_pmic_device_port.c
  group bc_module/g_sensor
    ../../../../bc_ros/bc_module/gsensor/: bc_gsensor.c bc_g_sensor_device_port.c bc_spi_gsensor.c bc_spi_gsensor_port.c
  group bc_moudle/ppg
    ../../../../bc_ros/bc_module/ppg/: bc_ppg.c bc_ppg_driver_port.c
  group bc_module/temper
    ../../../../bc_ros/bc_module/temp/: bc_temp.c bc_temp_port.c
  group bc_moudle/spi_flash
    ../../../../bc_ros/bc_module/spi_flash/: bc_spi_flash.c bc_spi_flash_port.c
  group bc_module/key
    ../../../../bc_ros/bc_module/key/: bc_key.c
  group bc_module/nfc
    ../../../../bc_ros/bc_module/nfc/: bc_nfc_read_st25r100_port.c
  group bc_module/wifi
    ../../../../bc_ros/bc_module/wifi/: bc_wifi_port.c bc_wifi.c
  group bc_moudle/led
    ../../../../bc_ros/bc_module/led/: bc_led_pwm.c bc_led.c bc_ic_led.c
  group bc_module/touch_button
    ../../../../bc_ros/bc_module/touch_button/: bc_touch_button.c bc_touch_button_device_port.c
  group bc_module/linear_motor
    ../../../../bc_ros/bc_module/linear_motor/: bc_linear_motor_ic.c bc_linear_motor_ic_port.c
  group bc_module/fuel_gauge
    ../../../../bc_ros/bc_module/fuel_gauge/: bc_fuel_gauge.c bc_fuel_gauge_port.c
  group bc_device/pmic
    ../../../../bc_ros/bc_device/yhm2712/: yhm2712.c
    ../../../../bc_ros/bc_device/sy6103/: sy6103.c
  group bc_device/g_sensor
    ../../../../bc_ros/bc_device/da267/: da267.c
    ../../../../bc_ros/bc_device/icm42688/: icm42688.c
  group bc_device/g_sensor/st/lsm6dso
    ../../../../bc_ros/bc_device/lsm6dsow/: lsm6dso.c lsm6sdo_port.c lsm6dso_reg.c
  group bc_device/g_sensor/tdk/icm42688
    ../../../../bc_ros/bc_device/Icm426xx/: Icm426xxDriver_HL.c Icm426xxDriver_HL_apex.c Icm426xxSelfTest.c Icm426xxTransport.c icm426xx_port.c
  group bc_device/ppg/hx3605
    ../../../../bc_ros/bc_device/hx3605/: hx3605.c hx3605_factory_test.c hx3605_hrs_agc.c hx3605_led_config.c hx3605_spo2_agc.c keil_m4_3605_spo2_20231122.lib m4_keil_3605_hrs_20230113_01S.lib
  group bc_device/ppg/gh/kernel
    ../../../../bc_ros/bc_device/gh3228T/kernel/: gh_demo.c gh_demo_hook.c gh_demo_protocol.c gh_demo_reg_array.c gh_demo_user.c libgh3x2x_drv_cortexM4l_band_keil_common.lib
  group bc_device/ppg/gh/moudle
    ../../../../bc_ros/bc_device/gh3228T/module/gh_agc/: gh_agc.c
    ../../../../bc_ros/bc_device/gh3228T/module/gh_ecg/: gh_ecg.c
    ../../../../bc_ros/bc_device/gh3228T/module/gh_protocol/: gh_datatrans.c gh_uprotocol.c gh_zip.c
    ../../../../bc_ros/bc_device/gh3228T/module/gh_soft_adt/: gh_multi_sen_pro.c
    ../../../../bc_ros/bc_device/gh3228T/module/gh_other/: gh_changeinttime.c gh_movedetect.c
  group bc_device/ppg/gh/driver
    ../../../../bc_ros/bc_device/gh3228T/driver/src/: gh_drv_config.c gh_drv_control.c gh_drv_dump.c gh_drv_interface.c
  group bc_device/ppg/gh/alg/lib
    ../../../../bc_ros/bc_device/gh3228T/algo_lib/COMMOM_DL/01_premium_and_exclusive/: cortex-m4_keil-armcc-5.06_ospace_common_dl.lib
    ../../../../bc_ros/bc_device/gh3228T/algo_lib/COMMOM_DSP/: cortex-m4_keil-armcc-5.06_ospace_common_dsp.lib
    ../../../../bc_ros/bc_device/gh3228T/algo_lib/HR/exclusive/: cortex-m4_keil-armcc-5.06_ospace_hr.lib
    ../../../../bc_ros/bc_device/gh3228T/algo_lib/SPO2/premium_and_exclusive/: cortex-m4_keil-armcc-5.06_ospace_spo2.lib
    ../../../../bc_ros/bc_device/gh3228T/algo_lib/NADT/02_premium/: cortex-m4_keil-armcc-5.06_ospace_nadt_cardiff.lib
    ../../../../bc_ros/bc_device/gh3228T/algo_lib/HRV/00_public_version/HRV_v2.4.6NC/00-算法库文件/goodix_dsp_hrv/: cortexM4_keil-armcc-5.06.lib
  group bc_device/ppg/gh/alg/lib/params
    ../../../../bc_ros/bc_device/gh3228T/alg_params/: goodix_hba_config.c goodix_spo2_config.c goodix_nadt_config.c
    ../../../../bc_ros/bc_device/gh3228T/alg_params/HR/04_EXCLUSIVE/: HRNet_knBasicWeights.c HRNet_knConfNetWeights.c HRNet_knMultiWeights.c HRNet_knSceneNetWeights.c HRNet_knSceneSwitchWeights.c HRNet_knSmallWeights.c HRNet_knTdfusionWeights.c HRNet_knWeights.c heart_net_org_dll.c heart_net_org_export.h
    ../../../../bc_ros/bc_device/gh3228T/alg_params/SPO2/02_PREMIUM_EXCLUSIVE/: pv_v2.1.0.0_spo2wrnet_for_GH3228T_cd023f.c
  group bc_device/ppg/gh/alg/call
    ../../../../bc_ros/bc_device/gh3228T/goodix_algo_call/src/: gh3x2x_demo_algo_call_adt.c gh3x2x_demo_algo_call_hr.c gh3x2x_demo_algo_call_hrv.c gh3x2x_demo_algo_call_nadt.c gh3x2x_demo_algo_call_bt.c gh3x2x_demo_algo_call_spo2.c
  group bc_device/ppg/gh/alg/appication
    ../../../../bc_ros/bc_device/gh3228T/goodix_algo_application/src/: gh3x2x_demo_accppg_sync.c gh3x2x_demo_algo_call.c gh3x2x_demo_algo_config.c gh3x2x_demo_algo_frame.c gh3x2x_demo_algo_hook.c gh3x2x_demo_algo_memory.c gh3x2x_demo_algo_reg_array.c gh3x2x_demo_strategy.c
    ../../../../bc_ros/bc_device/gh3228T/alg_params/: goodix_hrv_config.c
  group bc_device/temper/gxt310
    ../../../../bc_ros/bc_device/temper/gxt310/: gxt310.c
  group bc_device/nfc/st25r100/rfal
    ../../../../bc_ros/bc_device/nfc/st/st25r100/RFAL/source/: rfal_analogConfig.c rfal_cd.c rfal_crc.c rfal_dlma.c rfal_dpo.c rfal_iso15693_2.c rfal_isoDep.c rfal_nfc.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_st25tb.c rfal_st25xv.c rfal_t1t.c rfal_t2t.c rfal_t4t.c
  group bc_device/nfc/st25r100/rfal/st25r100
    ../../../../bc_ros/bc_device/nfc/st/st25r100/RFAL/source/st25r200/: rfal_rfst25r200.c st25r200.c st25r200_com.c st25r200_irq.c
    ../../../../bc_ros/bc_device/nfc/st/st25r100/: plf_adaptation.c
  group bc_device/ic_led/tx1812n5
    ../../../../bc_ros/bc_device/ic_led/tx1812n5/: tx1812n5.c
  group bc_device/touch_button
    ../../../../bc_ros/bc_device/touch_button/IQS323/: IQS323.c
    ../../../../bc_ros/bc_device/touch_button/IQS7211E/: IQS7211E.c
  group bc_device/motor/aw86235csr
    ../../../../bc_ros/bc_device/aw86235/: aw8623x.c haptic_nv.c haptic_nv_config.c haptic_nv_params.c
  group bc_device/cw221x
    ../../../../bc_ros/bc_device/cw221x/: Cellwise_CW221X_Driver_V1.2.1.c
  group bc_rtos
    ../../../../bc_ros/bc_module/queue/: bc_queue.c
    ../../../../bc_ros/bc_module/sem/: bc_sem.c
    ../../../../bc_ros/bc_rtos/: bc_rtos.c
  group bc_algorithm
    ../../../../bc_ros/bc_algorithm/: bc_algorithm.lib
  group bc_driver
    ../../../../bc_ros/bc_driver/bsp/src/: bsp.c bsp_rtc.c bsp_sys.c bsp_adc.c bsp_spi1.c bsp_spi2.c bsp_flash.c bsp_i2c0.c bsp_i2c1.c bsp_pwm0.c bsp_pwm1.c bsp_io_input.c bsp_io_output.c bsp_soft__i2c2.c bsp_soft__i2c3.c bsp_soft__i2c4.c bsp_soft__i2c5.c bsp_stacmd.c bsp_watchdog.c bsp_soft__i2c6.c bsp_soft_spi3.c
  group bc_util
    ../../../../bc_ros/bc_util/: bc_util.c crc.c crcLib.c
    ../../../../bc_ros/bc_util/bc_log/: bc_logger.c
    ../../../../bc_ros/bc_util/bc_delay/: bc_delay.c
  group BC_Ble
    ../../../../bc_ros/bc_module/ble/src/: bc_ble.c bc_ble_adv.c bc_ble_dfu.c bc_ble_gap.c bc_ble_gatt.c bc_ble_hids_service.c bc_ble_info_service.c bc_ble_modu_interface.c
  group LittleFS
    ../../../../bc_ros/bc_module/file/LittleFS/: lfs.c lfs_util.c lfs_port.c
  group SFUD
    ../../../../bc_ros/bc_module/spi_flash/sfud/src/: sfud.c sfud_sfdp.c
    ../../../../bc_ros/bc_module/spi_flash/sfud/port/: sfud_port.c
  group FAL
    ../../../../bc_ros/bc_module/DB/FAL/src/: fal.c fal_flash.c fal_partition.c
    ../../../../bc_ros/bc_module/DB/: bc_flash_port.c
  group FlashDB
    ../../../../bc_ros/bc_module/DB/FlashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_utils.c fdb_tsdb.c
  group Q_Multi_Button
    ../../../../bc_ros/bc_module/touch_button/q_multi_button/: q_multi_button.c
  group Q_Device
    ../../../../bc_ros/bc_driver/q_device/src/: q_device.c q_init.c
  group opus/src
    ../../../../bc_ros/bc_module/opus/opus-1.5.2/src/: opus.c opus_decoder.c opus_encoder.c repacketizer.c analysis.c mlp_data.c mlp.c extensions.c
  group opus/celt
    ../../../../bc_ros/bc_module/opus/opus-1.5.2/celt/: celt.c celt_decoder.c celt_encoder.c bands.c celt_lpc.c cwrs.c entcode.c entdec.c entenc.c kiss_fft.c laplace.c mathops.c mdct.c modes.c pitch.c quant_bands.c rate.c vq.c
  group opus/slik
    ../../../../bc_ros/bc_module/opus/opus-1.5.2/silk/: A2NLSF.c ana_filt_bank_1.c biquad_alt.c bwexpander.c bwexpander_32.c check_control_input.c CNG.c code_signs.c control_audio_bandwidth.c control_codec.c control_SNR.c debug.c dec_API.c decode_core.c decode_frame.c decode_indices.c decode_parameters.c decode_pitch.c decode_pulses.c decoder_set_fs.c enc_API.c encode_indices.c encode_pulses.c gain_quant.c HP_variable_cutoff.c init_decoder.c init_encoder.c inner_prod_aligned.c interpolate.c lin2log.c log2lin.c LP_variable_cutoff.c LPC_analysis_filter.c LPC_fit.c LPC_inv_pred_gain.c NLSF_decode.c NLSF_del_dec_quant.c NLSF_encode.c NLSF_stabilize.c NLSF_unpack.c NLSF_VQ.c NLSF2A.c NSQ.c NSQ_del_dec.c pitch_est_tables.c PLC.c process_NLSFs.c quant_LTP_gains.c resampler.c resampler_down2.c resampler_down2_3.c resampler_private_AR2.c resampler_private_down_FIR.c resampler_private_IIR_FIR.c resampler_private_up2_HQ.c resampler_rom.c shell_coder.c sigm_Q15.c sort.c stereo_decode_pred.c stereo_encode_pred.c stereo_find_predictor.c stereo_LR_to_MS.c stereo_MS_to_LR.c stereo_quant_pred.c sum_sqr_shift.c table_LSF_cos.c tables_gain.c tables_LTP.c tables_NLSF_CB_NB_MB.c tables_NLSF_CB_WB.c tables_other.c tables_pitch_lag.c tables_pulses_per_block.c VAD.c VQ_WMat_EC.c NLSF_VQ_weights_laroia.c
  group opus/slik/fixed
    ../../../../bc_ros/bc_module/opus/opus-1.5.2/silk/fixed/: apply_sine_window_FIX.c autocorr_FIX.c burg_modified_FIX.c corrMatrix_FIX.c encode_frame_FIX.c find_LPC_FIX.c find_LTP_FIX.c find_pitch_lags_FIX.c find_pred_coefs_FIX.c k2a_FIX.c k2a_Q16_FIX.c LTP_analysis_filter_FIX.c LTP_scale_ctrl_FIX.c noise_shape_analysis_FIX.c pitch_analysis_core_FIX.c process_gains_FIX.c regularize_correlations_FIX.c residual_energy_FIX.c residual_energy16_FIX.c schur_FIX.c schur64_FIX.c vector_ops_FIX.c warped_autocorrelation_FIX.c
  group freertos
    ../../external/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../external/freertos/source/portable/MemMang/: heap_4.c
    ../../external/freertos/portable/ARM/nrf52/: port.c
    ../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group UTF8/UTF16 converter
    ../../external/utf_converter/: utf.c
  group nRF_BLE
    ../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../components/ble/ble_advertising/: ble_advertising.c
    ../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../components/ble/ble_services/ble_hids/: ble_hids.c
    ../../components/ble/peer_manager/: pm_buffer.c security_dispatcher.c security_manager.c peer_manager.c peer_manager_handler.c peer_id.c peer_database.c peer_data_storage.c id_manager.c gatts_cache_manager.c gatt_cache_manager.c
  group nRF_DFU
    ../../components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_bonded.c ble_dfu_unbonded.c
  group nRF_Drivers
    ../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c nrf_drv_twi.c nrf_drv_spi.c
    ../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c nrfx_twim.c nrfx_twis.c nrfx_rtc.c nrfx_twi.c nrfx_saadc.c nrfx_wdt.c nrfx_pwm.c nrfx_power.c nrfx_pdm.c nrfx_nfct.c nrfx_spi.c nrfx_spim.c nrfx_timer.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../modules/nrfx/soc/: nrfx_atomic.c
  group nRF_Libraries
    ../../components/libraries/button/: app_button.c
    ../../components/libraries/scheduler/: app_scheduler.c
    ../../components/libraries/hardfault/: hardfault_implementation.c
    ../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/sortlist/: nrf_sortlist.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/libraries/timer/: app_timer_freertos.c
    ../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../components/libraries/fds/: fds.c
  group nRF_SVC
    ../../components/libraries/bootloader/dfu/: nrf_dfu_svci.c
  group nRF_Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target 1.17.1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: ..\..\..\dfu\ota_bat\creat_1171_dfu.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BL_SETTINGS_ACCESS_ONLY NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192 CONFIG_NFCT_PINS_AS_GPIOS HANDWARE_1_17_1 ST25R200 BLE_POWER_TESTx
  c misc: --reduce_paths
  c include: ..\..\components;..\..\components\ble\ble_advertising;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\crc16;..\..\components\libraries\delay;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fifo;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\uart;..\..\components\libraries\util;..\..\components\libraries\mutex;..\..\components\softdevice\common;..\..\components\softdevice\s140\headers;..\..\components\softdevice\s140\headers\nrf52;..\..\external\fprintf;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\components\libraries\bootloader;..\..\components\libraries\bootloader\dfu;..\..\components\libraries\bootloader\ble_dfu;..\..\components\ble\ble_services\ble_dfu;..\..\components\ble\peer_manager;..\..\external\freertos\source;..\..\external\freertos\source\portable\MemMang;..\..\external\freertos\portable\CMSIS\nrf52;..\..\external\freertos\source\include;..\..\external\freertos\portable\ARM\nrf52;..\..\components\libraries\fstorage;..\..\user\inc;..\..\..\..\bc_ros\bc_module\ble\src;..\..\..\..\bc_ros\bc_module\ble\inc;..\..\..\..\bc_ros\bc_util;..\..\..\..\bc_ros\bc_util\bc_log;..\..\..\..\bc_ros\bc_util\bc_delay;..\..\..\..\bc_ros\bc_config;..\..\..\..\bc_ros\bc_driver\q_device\src;..\..\..\..\bc_ros\bc_driver\q_device\inc;..\..\..\..\bc_ros\bc_driver\bsp\src;..\..\..\..\bc_ros\bc_driver\bsp\inc;..\..\..\..\bc_ros\bc_module\device_info;..\..\..\..\bc_ros\bc_module\strategy_value;..\..\components\ble\peer_manager;..\..\components\ble\ble_services\ble_hids;..\..\components\libraries\fds;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_dis;..\..\..\..\bc_ros\bc_module;..\..\..\..\bc_ros\bc_module\queue;..\..\..\..\bc_ros\bc_rtos;..\..\..\..\bc_ros\bc_module\sem;..\..\..\..\bc_ros\bc_application;..\..\..\..\bc_ros\bc_device\yhm2712;..\..\..\..\bc_ros\bc_module\pmic;..\..\..\..\bc_ros\bc_module\bc_ldo_switch;..\..\..\..\bc_ros\bc_module\rtc;..\..\..\..\bc_ros\bc_device\icm42688;..\..\..\..\bc_ros\bc_module\gsensor;..\..\..\..\bc_ros\bc_module\i2c_bus;..\..\..\..\bc_ros\bc_module\ppg;..\..\..\..\bc_ros\bc_device\hx3605;..\..\..\..\bc_ros\bc_algorithm;..\..\..\..\bc_ros\bc_device\temper\gxt310;..\..\..\..\bc_ros\bc_module\temp;..\..\..\..\bc_ros\bc_module\wtd;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\HR;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\SPO2;..\..\..\..\bc_ros\bc_device\gh3228T\driver\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_application\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_call\inc;..\..\..\..\bc_ros\bc_device\gh3228T\kernel;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_agc;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_other;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_ecg;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_protocol;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_soft_adt;..\..\..\..\bc_ros\bc_module\file\LittleFS;..\..\..\..\bc_ros\bc_module\spi_flash;..\..\..\..\bc_ros\bc_module\spi_flash\sfud\inc;..\..\..\..\bc_ros\bc_module\touch_button\q_multi_button;..\..\..\..\bc_ros\bc_module\key;..\..\..\..\bc_ros\bc_module\motor;..\..\..\..\bc_ros\bc_device\sy6103;..\..\..\..\bc_ros\bc_device\da267;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\include;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source\st25r200;..\..\..\..\bc_ros\bc_module\nfc;..\..\..\..\bc_ros\bc_module\pdm;..\..\..\..\bc_ros\bc_module\led;..\..\..\..\bc_ros\bc_module\DB;..\..\..\..\bc_ros\bc_module\DB\FAL\inc;..\..\..\..\bc_ros\bc_module\DB\FlashDB\inc
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20004758 size 0x3be70
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
target 1.18.1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: app +hex
  AfterMake: ..\..\..\dfu\ota_bat\creat_1181_dfu.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BL_SETTINGS_ACCESS_ONLY NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192 CONFIG_NFCT_PINS_AS_GPIOS HANDWARE_1_18_1 ST25R200 BLE_POWER_TESTx
  c misc: --reduce_paths
  c include: ..\..\components;..\..\components\ble\ble_advertising;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\crc16;..\..\components\libraries\delay;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fifo;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\uart;..\..\components\libraries\util;..\..\components\libraries\mutex;..\..\components\softdevice\common;..\..\components\softdevice\s140\headers;..\..\components\softdevice\s140\headers\nrf52;..\..\external\fprintf;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\components\libraries\bootloader;..\..\components\libraries\bootloader\dfu;..\..\components\libraries\bootloader\ble_dfu;..\..\components\ble\ble_services\ble_dfu;..\..\components\ble\peer_manager;..\..\external\freertos\source;..\..\external\freertos\source\portable\MemMang;..\..\external\freertos\portable\CMSIS\nrf52;..\..\external\freertos\source\include;..\..\external\freertos\portable\ARM\nrf52;..\..\components\libraries\fstorage;..\..\user\inc;..\..\..\..\bc_ros\bc_module\ble\src;..\..\..\..\bc_ros\bc_module\ble\inc;..\..\..\..\bc_ros\bc_util;..\..\..\..\bc_ros\bc_util\bc_log;..\..\..\..\bc_ros\bc_util\bc_delay;..\..\..\..\bc_ros\bc_config;..\..\..\..\bc_ros\bc_driver\q_device\src;..\..\..\..\bc_ros\bc_driver\q_device\inc;..\..\..\..\bc_ros\bc_driver\bsp\src;..\..\..\..\bc_ros\bc_driver\bsp\inc;..\..\..\..\bc_ros\bc_module\device_info;..\..\..\..\bc_ros\bc_module\strategy_value;..\..\components\ble\peer_manager;..\..\components\ble\ble_services\ble_hids;..\..\components\libraries\fds;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_dis;..\..\..\..\bc_ros\bc_module;..\..\..\..\bc_ros\bc_module\queue;..\..\..\..\bc_ros\bc_rtos;..\..\..\..\bc_ros\bc_module\sem;..\..\..\..\bc_ros\bc_application;..\..\..\..\bc_ros\bc_device\yhm2712;..\..\..\..\bc_ros\bc_module\pmic;..\..\..\..\bc_ros\bc_module\bc_ldo_switch;..\..\..\..\bc_ros\bc_module\rtc;..\..\..\..\bc_ros\bc_device\icm42688;..\..\..\..\bc_ros\bc_module\gsensor;..\..\..\..\bc_ros\bc_module\i2c_bus;..\..\..\..\bc_ros\bc_module\ppg;..\..\..\..\bc_ros\bc_device\hx3605;..\..\..\..\bc_ros\bc_algorithm;..\..\..\..\bc_ros\bc_device\temper\gxt310;..\..\..\..\bc_ros\bc_module\temp;..\..\..\..\bc_ros\bc_module\wtd;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\HR;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\SPO2;..\..\..\..\bc_ros\bc_device\gh3228T\driver\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_application\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_call\inc;..\..\..\..\bc_ros\bc_device\gh3228T\kernel;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_agc;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_other;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_ecg;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_protocol;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_soft_adt;..\..\..\..\bc_ros\bc_module\file\LittleFS;..\..\..\..\bc_ros\bc_module\spi_flash;..\..\..\..\bc_ros\bc_module\spi_flash\sfud\inc;..\..\..\..\bc_ros\bc_module\touch_button\q_multi_button;..\..\..\..\bc_ros\bc_module\key;..\..\..\..\bc_ros\bc_module\motor;..\..\..\..\bc_ros\bc_device\sy6103;..\..\..\..\bc_ros\bc_device\da267;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\include;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source\st25r200;..\..\..\..\bc_ros\bc_module\nfc;..\..\..\..\bc_ros\bc_device\touch_button\IQS7211E;..\..\..\..\bc_ros\bc_module\touch_button;..\..\..\..\bc_ros\bc_module\pdm;..\..\..\..\bc_ros\bc_module\led;..\..\..\..\bc_ros\bc_device\lsm6dsow;..\..\..\..\bc_ros\bc_module\DB;..\..\..\..\bc_ros\bc_module\DB\FlashDB\inc;..\..\..\..\bc_ros\bc_module\DB\FlashDB\src;..\..\..\..\bc_ros\bc_module\DB\FAL\inc
  asm define: as above
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20004758 size 0x3be70
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
target 1.19.1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: app +hex
  AfterMake: ..\..\..\dfu\ota_bat\creat_1191_dfu.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BL_SETTINGS_ACCESS_ONLY NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESETx FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192 CONFIG_NFCT_PINS_AS_GPIOS OPUS_BUILD VAR_ARRAYS FIXED_POINT DISABLE_FLOAT_API REMOVE_FOR_MALLOC ICM42688P HANDWARE_1_19_1 ST25R200 BLE_POWER_TESTx
  c misc: --reduce_paths
  c include: ..\..\components;..\..\components\ble\ble_advertising;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\crc16;..\..\components\libraries\delay;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fifo;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\uart;..\..\components\libraries\util;..\..\components\libraries\mutex;..\..\components\softdevice\common;..\..\components\softdevice\s140\headers;..\..\components\softdevice\s140\headers\nrf52;..\..\external\fprintf;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\components\libraries\bootloader;..\..\components\libraries\bootloader\dfu;..\..\components\libraries\bootloader\ble_dfu;..\..\components\ble\ble_services\ble_dfu;..\..\components\ble\peer_manager;..\..\external\freertos\source;..\..\external\freertos\source\portable\MemMang;..\..\external\freertos\portable\CMSIS\nrf52;..\..\external\freertos\source\include;..\..\external\freertos\portable\ARM\nrf52;..\..\components\libraries\fstorage;..\..\user\inc;..\..\..\..\bc_ros\bc_module\ble\src;..\..\..\..\bc_ros\bc_module\ble\inc;..\..\..\..\bc_ros\bc_util;..\..\..\..\bc_ros\bc_util\bc_log;..\..\..\..\bc_ros\bc_util\bc_delay;..\..\..\..\bc_ros\bc_config;..\..\..\..\bc_ros\bc_driver\q_device\src;..\..\..\..\bc_ros\bc_driver\q_device\inc;..\..\..\..\bc_ros\bc_driver\bsp\src;..\..\..\..\bc_ros\bc_driver\bsp\inc;..\..\..\..\bc_ros\bc_module\device_info;..\..\..\..\bc_ros\bc_module\strategy_value;..\..\components\ble\peer_manager;..\..\components\ble\ble_services\ble_hids;..\..\components\libraries\fds;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_dis;..\..\..\..\bc_ros\bc_module;..\..\..\..\bc_ros\bc_module\queue;..\..\..\..\bc_ros\bc_rtos;..\..\..\..\bc_ros\bc_module\sem;..\..\..\..\bc_ros\bc_application;..\..\..\..\bc_ros\bc_device\yhm2712;..\..\..\..\bc_ros\bc_module\pmic;..\..\..\..\bc_ros\bc_module\bc_ldo_switch;..\..\..\..\bc_ros\bc_module\rtc;..\..\..\..\bc_ros\bc_device\icm42688;..\..\..\..\bc_ros\bc_module\gsensor;..\..\..\..\bc_ros\bc_module\i2c_bus;..\..\..\..\bc_ros\bc_module\ppg;..\..\..\..\bc_ros\bc_device\hx3605;..\..\..\..\bc_ros\bc_algorithm;..\..\..\..\bc_ros\bc_device\temper\gxt310;..\..\..\..\bc_ros\bc_module\temp;..\..\..\..\bc_ros\bc_module\wtd;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\HR;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\SPO2;..\..\..\..\bc_ros\bc_device\gh3228T\driver\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_application\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_call\inc;..\..\..\..\bc_ros\bc_device\gh3228T\kernel;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_agc;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_other;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_ecg;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_protocol;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_soft_adt;..\..\..\..\bc_ros\bc_module\file\LittleFS;..\..\..\..\bc_ros\bc_module\spi_flash;..\..\..\..\bc_ros\bc_module\spi_flash\sfud\inc;..\..\..\..\bc_ros\bc_module\touch_button\q_multi_button;..\..\..\..\bc_ros\bc_module\key;..\..\..\..\bc_ros\bc_module\motor;..\..\..\..\bc_ros\bc_device\sy6103;..\..\..\..\bc_ros\bc_device\da267;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\include;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source\st25r200;..\..\..\..\bc_ros\bc_module\nfc;..\..\..\..\bc_ros\bc_device\touch_button\IQS7211E;..\..\..\..\bc_ros\bc_module\touch_button;..\..\..\..\bc_ros\bc_module\pdm;..\..\..\..\bc_ros\bc_module\led;..\..\..\..\bc_ros\bc_device\lsm6dsow;..\..\..\..\bc_ros\bc_module\DB;..\..\..\..\bc_ros\bc_module\DB\FAL\inc;..\..\..\..\bc_ros\bc_module\DB\FlashDB\inc;..\..\..\..\bc_ros\bc_module\wifi;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\src;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\celt;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\include;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk\fixed;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk\float;..\..\..\..\bc_ros\bc_module\DB\FlashDB\src;..\..\..\..\bc_ros\bc_device\Icm426xx
  asm define: as above
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20004758 size 0x3be70
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
target 1.23.1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: app +hex
  AfterMake: ..\..\..\dfu\ota_bat\creat_1231_dfu.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BL_SETTINGS_ACCESS_ONLY NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056  FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192 CONFIG_NFCT_PINS_AS_GPIOS OPUS_BUILD VAR_ARRAYS FIXED_POINT DISABLE_FLOAT_API REMOVE_FOR_MALLOC ICM42688P HANDWARE_1_23_1 ST25R200 BLE_POWER_TESTx
  c misc: --reduce_paths
  c include: ..\..\components;..\..\components\ble\ble_advertising;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\crc16;..\..\components\libraries\delay;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fifo;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\uart;..\..\components\libraries\util;..\..\components\libraries\mutex;..\..\components\softdevice\common;..\..\components\softdevice\s140\headers;..\..\components\softdevice\s140\headers\nrf52;..\..\external\fprintf;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\components\libraries\bootloader;..\..\components\libraries\bootloader\dfu;..\..\components\libraries\bootloader\ble_dfu;..\..\components\ble\ble_services\ble_dfu;..\..\components\ble\peer_manager;..\..\external\freertos\source;..\..\external\freertos\source\portable\MemMang;..\..\external\freertos\portable\CMSIS\nrf52;..\..\external\freertos\source\include;..\..\external\freertos\portable\ARM\nrf52;..\..\components\libraries\fstorage;..\..\user\inc;..\..\..\..\bc_ros\bc_module\ble\src;..\..\..\..\bc_ros\bc_module\ble\inc;..\..\..\..\bc_ros\bc_util;..\..\..\..\bc_ros\bc_util\bc_log;..\..\..\..\bc_ros\bc_util\bc_delay;..\..\..\..\bc_ros\bc_config;..\..\..\..\bc_ros\bc_driver\q_device\src;..\..\..\..\bc_ros\bc_driver\q_device\inc;..\..\..\..\bc_ros\bc_driver\bsp\src;..\..\..\..\bc_ros\bc_driver\bsp\inc;..\..\..\..\bc_ros\bc_module\device_info;..\..\..\..\bc_ros\bc_module\strategy_value;..\..\components\ble\peer_manager;..\..\components\ble\ble_services\ble_hids;..\..\components\libraries\fds;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_dis;..\..\..\..\bc_ros\bc_module;..\..\..\..\bc_ros\bc_module\queue;..\..\..\..\bc_ros\bc_rtos;..\..\..\..\bc_ros\bc_module\sem;..\..\..\..\bc_ros\bc_application;..\..\..\..\bc_ros\bc_device\yhm2712;..\..\..\..\bc_ros\bc_module\pmic;..\..\..\..\bc_ros\bc_module\bc_ldo_switch;..\..\..\..\bc_ros\bc_module\rtc;..\..\..\..\bc_ros\bc_device\icm42688;..\..\..\..\bc_ros\bc_module\gsensor;..\..\..\..\bc_ros\bc_module\i2c_bus;..\..\..\..\bc_ros\bc_module\ppg;..\..\..\..\bc_ros\bc_device\hx3605;..\..\..\..\bc_ros\bc_algorithm;..\..\..\..\bc_ros\bc_device\temper\gxt310;..\..\..\..\bc_ros\bc_module\temp;..\..\..\..\bc_ros\bc_module\wtd;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\HR;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\SPO2;..\..\..\..\bc_ros\bc_device\gh3228T\driver\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_application\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_call\inc;..\..\..\..\bc_ros\bc_device\gh3228T\kernel;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_agc;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_other;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_ecg;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_protocol;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_soft_adt;..\..\..\..\bc_ros\bc_module\file\LittleFS;..\..\..\..\bc_ros\bc_module\spi_flash;..\..\..\..\bc_ros\bc_module\spi_flash\sfud\inc;..\..\..\..\bc_ros\bc_module\touch_button\q_multi_button;..\..\..\..\bc_ros\bc_module\key;..\..\..\..\bc_ros\bc_module\motor;..\..\..\..\bc_ros\bc_device\sy6103;..\..\..\..\bc_ros\bc_device\da267;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\include;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source\st25r200;..\..\..\..\bc_ros\bc_module\nfc;..\..\..\..\bc_ros\bc_device\touch_button\IQS7211E;..\..\..\..\bc_ros\bc_module\touch_button;..\..\..\..\bc_ros\bc_module\pdm;..\..\..\..\bc_ros\bc_module\led;..\..\..\..\bc_ros\bc_device\lsm6dsow;..\..\..\..\bc_ros\bc_module\DB;..\..\..\..\bc_ros\bc_module\DB\FAL\inc;..\..\..\..\bc_ros\bc_module\DB\FlashDB\inc;..\..\..\..\bc_ros\bc_module\wifi;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\src;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\celt;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\include;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk\fixed;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk\float;..\..\..\..\bc_ros\bc_module\DB\FlashDB\src;..\..\..\..\bc_ros\bc_device\Icm426xx;..\..\..\..\bc_ros\bc_device\ic_led\tx1812n5;..\..\..\..\bc_ros\bc_module\led;..\..\..\..\bc_ros\bc_device\aw86235;..\..\..\..\bc_ros\bc_module\linear_motor;..\..\..\..\bc_ros\bc_module\timer
  asm define: as above
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20004758 size 0x3be70
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
target 1.23.2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: app +hex
  AfterMake: ..\..\..\dfu\ota_bat\creat_1232_dfu.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BL_SETTINGS_ACCESS_ONLY NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESETx FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192 CONFIG_NFCT_PINS_AS_GPIOS OPUS_BUILD VAR_ARRAYS FIXED_POINT DISABLE_FLOAT_API REMOVE_FOR_MALLOC ICM42688P HANDWARE_1_23_1 HANDWARE_1_23_2 ST25R200 BLE_POWER_TESTx
  c misc: --reduce_paths
  c include: ..\..\components;..\..\components\ble\ble_advertising;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\crc16;..\..\components\libraries\delay;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fifo;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\uart;..\..\components\libraries\util;..\..\components\libraries\mutex;..\..\components\softdevice\common;..\..\components\softdevice\s140\headers;..\..\components\softdevice\s140\headers\nrf52;..\..\external\fprintf;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\components\libraries\bootloader;..\..\components\libraries\bootloader\dfu;..\..\components\libraries\bootloader\ble_dfu;..\..\components\ble\ble_services\ble_dfu;..\..\components\ble\peer_manager;..\..\external\freertos\source;..\..\external\freertos\source\portable\MemMang;..\..\external\freertos\portable\CMSIS\nrf52;..\..\external\freertos\source\include;..\..\external\freertos\portable\ARM\nrf52;..\..\components\libraries\fstorage;..\..\user\inc;..\..\..\..\bc_ros\bc_module\ble\src;..\..\..\..\bc_ros\bc_module\ble\inc;..\..\..\..\bc_ros\bc_util;..\..\..\..\bc_ros\bc_util\bc_log;..\..\..\..\bc_ros\bc_util\bc_delay;..\..\..\..\bc_ros\bc_config;..\..\..\..\bc_ros\bc_driver\q_device\src;..\..\..\..\bc_ros\bc_driver\q_device\inc;..\..\..\..\bc_ros\bc_driver\bsp\src;..\..\..\..\bc_ros\bc_driver\bsp\inc;..\..\..\..\bc_ros\bc_module\device_info;..\..\..\..\bc_ros\bc_module\strategy_value;..\..\components\ble\peer_manager;..\..\components\ble\ble_services\ble_hids;..\..\components\libraries\fds;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_dis;..\..\..\..\bc_ros\bc_module;..\..\..\..\bc_ros\bc_module\queue;..\..\..\..\bc_ros\bc_rtos;..\..\..\..\bc_ros\bc_module\sem;..\..\..\..\bc_ros\bc_application;..\..\..\..\bc_ros\bc_device\yhm2712;..\..\..\..\bc_ros\bc_module\pmic;..\..\..\..\bc_ros\bc_module\bc_ldo_switch;..\..\..\..\bc_ros\bc_module\rtc;..\..\..\..\bc_ros\bc_device\icm42688;..\..\..\..\bc_ros\bc_module\gsensor;..\..\..\..\bc_ros\bc_module\i2c_bus;..\..\..\..\bc_ros\bc_module\ppg;..\..\..\..\bc_ros\bc_device\hx3605;..\..\..\..\bc_ros\bc_algorithm;..\..\..\..\bc_ros\bc_device\temper\gxt310;..\..\..\..\bc_ros\bc_module\temp;..\..\..\..\bc_ros\bc_module\wtd;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\HR;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\SPO2;..\..\..\..\bc_ros\bc_device\gh3228T\driver\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_application\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_call\inc;..\..\..\..\bc_ros\bc_device\gh3228T\kernel;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_agc;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_other;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_ecg;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_protocol;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_soft_adt;..\..\..\..\bc_ros\bc_module\file\LittleFS;..\..\..\..\bc_ros\bc_module\spi_flash;..\..\..\..\bc_ros\bc_module\spi_flash\sfud\inc;..\..\..\..\bc_ros\bc_module\touch_button\q_multi_button;..\..\..\..\bc_ros\bc_module\key;..\..\..\..\bc_ros\bc_module\motor;..\..\..\..\bc_ros\bc_device\sy6103;..\..\..\..\bc_ros\bc_device\da267;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\include;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source\st25r200;..\..\..\..\bc_ros\bc_module\nfc;..\..\..\..\bc_ros\bc_device\touch_button\IQS7211E;..\..\..\..\bc_ros\bc_module\touch_button;..\..\..\..\bc_ros\bc_module\pdm;..\..\..\..\bc_ros\bc_module\led;..\..\..\..\bc_ros\bc_device\lsm6dsow;..\..\..\..\bc_ros\bc_module\DB;..\..\..\..\bc_ros\bc_module\DB\FAL\inc;..\..\..\..\bc_ros\bc_module\DB\FlashDB\inc;..\..\..\..\bc_ros\bc_module\wifi;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\src;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\celt;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\include;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk\fixed;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk\float;..\..\..\..\bc_ros\bc_module\DB\FlashDB\src;..\..\..\..\bc_ros\bc_device\Icm426xx;..\..\..\..\bc_ros\bc_device\ic_led\tx1812n5;..\..\..\..\bc_ros\bc_module\led
  asm define: as above
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20004758 size 0x3be70
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
target 1.23.3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: app +hex
  AfterMake: ..\..\..\dfu\ota_bat\creat_1233_dfu.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BL_SETTINGS_ACCESS_ONLY NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESETx FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192 CONFIG_NFCT_PINS_AS_GPIOS OPUS_BUILD VAR_ARRAYS FIXED_POINT DISABLE_FLOAT_API REMOVE_FOR_MALLOC ICM42688P HANDWARE_1_23_1  HANDWARE_1_23_3 ST25R200 BLE_POWER_TESTx
  c misc: --reduce_paths
  c include: ..\..\components;..\..\components\ble\ble_advertising;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\crc16;..\..\components\libraries\delay;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fifo;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\uart;..\..\components\libraries\util;..\..\components\libraries\mutex;..\..\components\softdevice\common;..\..\components\softdevice\s140\headers;..\..\components\softdevice\s140\headers\nrf52;..\..\external\fprintf;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\components\libraries\bootloader;..\..\components\libraries\bootloader\dfu;..\..\components\libraries\bootloader\ble_dfu;..\..\components\ble\ble_services\ble_dfu;..\..\components\ble\peer_manager;..\..\external\freertos\source;..\..\external\freertos\source\portable\MemMang;..\..\external\freertos\portable\CMSIS\nrf52;..\..\external\freertos\source\include;..\..\external\freertos\portable\ARM\nrf52;..\..\components\libraries\fstorage;..\..\user\inc;..\..\..\..\bc_ros\bc_module\ble\src;..\..\..\..\bc_ros\bc_module\ble\inc;..\..\..\..\bc_ros\bc_util;..\..\..\..\bc_ros\bc_util\bc_log;..\..\..\..\bc_ros\bc_util\bc_delay;..\..\..\..\bc_ros\bc_config;..\..\..\..\bc_ros\bc_driver\q_device\src;..\..\..\..\bc_ros\bc_driver\q_device\inc;..\..\..\..\bc_ros\bc_driver\bsp\src;..\..\..\..\bc_ros\bc_driver\bsp\inc;..\..\..\..\bc_ros\bc_module\device_info;..\..\..\..\bc_ros\bc_module\strategy_value;..\..\components\ble\peer_manager;..\..\components\ble\ble_services\ble_hids;..\..\components\libraries\fds;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_dis;..\..\..\..\bc_ros\bc_module;..\..\..\..\bc_ros\bc_module\queue;..\..\..\..\bc_ros\bc_rtos;..\..\..\..\bc_ros\bc_module\sem;..\..\..\..\bc_ros\bc_application;..\..\..\..\bc_ros\bc_device\yhm2712;..\..\..\..\bc_ros\bc_module\pmic;..\..\..\..\bc_ros\bc_module\bc_ldo_switch;..\..\..\..\bc_ros\bc_module\rtc;..\..\..\..\bc_ros\bc_device\icm42688;..\..\..\..\bc_ros\bc_module\gsensor;..\..\..\..\bc_ros\bc_module\i2c_bus;..\..\..\..\bc_ros\bc_module\ppg;..\..\..\..\bc_ros\bc_device\hx3605;..\..\..\..\bc_ros\bc_algorithm;..\..\..\..\bc_ros\bc_device\temper\gxt310;..\..\..\..\bc_ros\bc_module\temp;..\..\..\..\bc_ros\bc_module\wtd;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\HR;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\SPO2;..\..\..\..\bc_ros\bc_device\gh3228T\driver\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_application\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_call\inc;..\..\..\..\bc_ros\bc_device\gh3228T\kernel;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_agc;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_other;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_ecg;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_protocol;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_soft_adt;..\..\..\..\bc_ros\bc_module\file\LittleFS;..\..\..\..\bc_ros\bc_module\spi_flash;..\..\..\..\bc_ros\bc_module\spi_flash\sfud\inc;..\..\..\..\bc_ros\bc_module\touch_button\q_multi_button;..\..\..\..\bc_ros\bc_module\key;..\..\..\..\bc_ros\bc_module\motor;..\..\..\..\bc_ros\bc_device\sy6103;..\..\..\..\bc_ros\bc_device\da267;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\include;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source\st25r200;..\..\..\..\bc_ros\bc_module\nfc;..\..\..\..\bc_ros\bc_device\touch_button\IQS7211E;..\..\..\..\bc_ros\bc_module\touch_button;..\..\..\..\bc_ros\bc_module\pdm;..\..\..\..\bc_ros\bc_module\led;..\..\..\..\bc_ros\bc_device\lsm6dsow;..\..\..\..\bc_ros\bc_module\DB;..\..\..\..\bc_ros\bc_module\DB\FAL\inc;..\..\..\..\bc_ros\bc_module\DB\FlashDB\inc;..\..\..\..\bc_ros\bc_module\wifi;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\src;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\celt;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\include;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk\fixed;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk\float;..\..\..\..\bc_ros\bc_module\DB\FlashDB\src;..\..\..\..\bc_ros\bc_device\Icm426xx;..\..\..\..\bc_ros\bc_device\ic_led\tx1812n5;..\..\..\..\bc_ros\bc_module\led;..\..\..\..\bc_ros\bc_module\linear_motor;..\..\..\..\bc_ros\bc_device\aw86235;..\..\..\..\bc_ros\bc_module\timer;..\..\..\..\bc_ros\bc_device\cw221x;..\..\..\..\bc_ros\bc_module\fuel_gauge
  asm define: as above
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20004758 size 0x3be70
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
target lib (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: alg_2.0 +hex (library)
  AfterMake: ..\..\..\dfu\ota_bat\creat_1191_dfu.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BL_SETTINGS_ACCESS_ONLY NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESETx FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192 CONFIG_NFCT_PINS_AS_GPIOS OPUS_BUILD VAR_ARRAYS FIXED_POINT DISABLE_FLOAT_API REMOVE_FOR_MALLOC HANDWARE_1_19_1 ST25R200 BLE_POWER_TESTx
  c misc: --reduce_paths
  c include: ..\..\components;..\..\components\ble\ble_advertising;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\crc16;..\..\components\libraries\delay;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fifo;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\uart;..\..\components\libraries\util;..\..\components\libraries\mutex;..\..\components\softdevice\common;..\..\components\softdevice\s140\headers;..\..\components\softdevice\s140\headers\nrf52;..\..\external\fprintf;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\components\libraries\bootloader;..\..\components\libraries\bootloader\dfu;..\..\components\libraries\bootloader\ble_dfu;..\..\components\ble\ble_services\ble_dfu;..\..\components\ble\peer_manager;..\..\external\freertos\source;..\..\external\freertos\source\portable\MemMang;..\..\external\freertos\portable\CMSIS\nrf52;..\..\external\freertos\source\include;..\..\external\freertos\portable\ARM\nrf52;..\..\components\libraries\fstorage;..\..\user\inc;..\..\..\..\bc_ros\bc_module\ble\src;..\..\..\..\bc_ros\bc_module\ble\inc;..\..\..\..\bc_ros\bc_util;..\..\..\..\bc_ros\bc_util\bc_log;..\..\..\..\bc_ros\bc_util\bc_delay;..\..\..\..\bc_ros\bc_config;..\..\..\..\bc_ros\bc_driver\q_device\src;..\..\..\..\bc_ros\bc_driver\q_device\inc;..\..\..\..\bc_ros\bc_driver\bsp\src;..\..\..\..\bc_ros\bc_driver\bsp\inc;..\..\..\..\bc_ros\bc_module\device_info;..\..\..\..\bc_ros\bc_module\strategy_value;..\..\components\ble\peer_manager;..\..\components\ble\ble_services\ble_hids;..\..\components\libraries\fds;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_dis;..\..\..\..\bc_ros\bc_module;..\..\..\..\bc_ros\bc_module\queue;..\..\..\..\bc_ros\bc_rtos;..\..\..\..\bc_ros\bc_module\sem;..\..\..\..\bc_ros\bc_application;..\..\..\..\bc_ros\bc_device\yhm2712;..\..\..\..\bc_ros\bc_module\pmic;..\..\..\..\bc_ros\bc_module\bc_ldo_switch;..\..\..\..\bc_ros\bc_module\rtc;..\..\..\..\bc_ros\bc_device\icm42688;..\..\..\..\bc_ros\bc_module\gsensor;..\..\..\..\bc_ros\bc_module\i2c_bus;..\..\..\..\bc_ros\bc_module\ppg;..\..\..\..\bc_ros\bc_device\hx3605;..\..\..\..\bc_ros\bc_algorithm;..\..\..\..\bc_ros\bc_device\temper\gxt310;..\..\..\..\bc_ros\bc_module\temp;..\..\..\..\bc_ros\bc_module\wtd;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\HR;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\SPO2;..\..\..\..\bc_ros\bc_device\gh3228T\driver\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_application\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_call\inc;..\..\..\..\bc_ros\bc_device\gh3228T\kernel;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_agc;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_other;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_ecg;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_protocol;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_soft_adt;..\..\..\..\bc_ros\bc_module\file\LittleFS;..\..\..\..\bc_ros\bc_module\spi_flash;..\..\..\..\bc_ros\bc_module\spi_flash\sfud\inc;..\..\..\..\bc_ros\bc_module\touch_button\q_multi_button;..\..\..\..\bc_ros\bc_module\key;..\..\..\..\bc_ros\bc_module\motor;..\..\..\..\bc_ros\bc_device\sy6103;..\..\..\..\bc_ros\bc_device\da267;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\include;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source\st25r200;..\..\..\..\bc_ros\bc_module\nfc;..\..\..\..\bc_ros\bc_device\touch_button\IQS7211E;..\..\..\..\bc_ros\bc_module\touch_button;..\..\..\..\bc_ros\bc_module\pdm;..\..\..\..\bc_ros\bc_module\led;..\..\..\..\bc_ros\bc_device\lsm6dsow;..\..\..\..\bc_ros\bc_module\DB;..\..\..\..\bc_ros\bc_module\DB\FAL\inc;..\..\..\..\bc_ros\bc_module\DB\FlashDB\inc;..\..\..\..\bc_ros\bc_module\wifi;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\src;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\celt;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\include;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk\fixed;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk\float
  asm define: as above
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20004758 size 0x3be70
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
target 1.23.2L (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: app +hex
  AfterMake: ..\..\..\dfu\ota_bat\creat_1232L_dfu.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BL_SETTINGS_ACCESS_ONLY NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESETx FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192 CONFIG_NFCT_PINS_AS_GPIOS OPUS_BUILD VAR_ARRAYS FIXED_POINT DISABLE_FLOAT_API REMOVE_FOR_MALLOC ICM42688P HANDWARE_1_23_1 HANDWARE_1_23_2 HANDWARE_1_23_2L ST25R200 BLE_POWER_TESTx
  c misc: --reduce_paths
  c include: as above
  asm define: as above
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20004758 size 0x3be70
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
target 1.23.4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: app +hex
  AfterMake: ..\..\..\dfu\ota_bat\creat_1234_dfu.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BL_SETTINGS_ACCESS_ONLY NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESETx FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192 CONFIG_NFCT_PINS_AS_GPIOS OPUS_BUILD VAR_ARRAYS FIXED_POINT DISABLE_FLOAT_API REMOVE_FOR_MALLOC ICM42688P HANDWARE_1_23_1  HANDWARE_1_23_4 ST25R200 BLE_POWER_TESTx
  c misc: --reduce_paths
  c include: as above
  asm define: as above
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20004758 size 0x3be70
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
target 1.23.2_one_sec (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: app +hex
  AfterMake: ..\..\..\dfu\ota_bat\creat_1232_one_sec_dfu.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BL_SETTINGS_ACCESS_ONLY NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESETx FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192 CONFIG_NFCT_PINS_AS_GPIOS OPUS_BUILD VAR_ARRAYS FIXED_POINT DISABLE_FLOAT_API REMOVE_FOR_MALLOC ICM42688P HANDWARE_1_23_1 HANDWARE_1_23_2 ST25R200 BLE_POWER_TESTx  HANDWARE_1_23_2_ONE_SEC
  c misc: --reduce_paths
  c include: as above
  asm define: as above
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20004758 size 0x3be70
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, CMSIS:CORE 5.4.0, CMSIS:CORE 6.0.0, Device:Startup 8.52.0, Device:Startup 8.35.0
