# Keil uVision project sudo_voice.uvprojx, settings and files
target Sudo Voice 1.23.2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: sudo_voice_candidate +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BL_SETTINGS_ACCESS_ONLY NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1 APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESETx FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192 CONFIG_NFCT_PINS_AS_GPIOS HANDWARE_1_23_1 HANDWARE_1_23_2 SUDO_VOICE_ONLY
  c misc: --reduce_paths
  c include: ..\..\components;..\..\components\ble\ble_advertising;..\..\components\ble\ble_link_ctx_manager;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\crc16;..\..\components\libraries\delay;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fifo;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\uart;..\..\components\libraries\util;..\..\components\libraries\mutex;..\..\components\softdevice\common;..\..\components\softdevice\s140\headers;..\..\components\softdevice\s140\headers\nrf52;..\..\external\fprintf;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\components\libraries\bootloader;..\..\components\libraries\bootloader\dfu;..\..\components\libraries\bootloader\ble_dfu;..\..\components\ble\ble_services\ble_dfu;..\..\components\ble\peer_manager;..\..\external\freertos\source;..\..\external\freertos\source\portable\MemMang;..\..\external\freertos\portable\CMSIS\nrf52;..\..\external\freertos\source\include;..\..\external\freertos\portable\ARM\nrf52;..\..\components\libraries\fstorage;..\..\user\inc;..\..\..\..\bc_ros\bc_module\ble\src;..\..\..\..\bc_ros\bc_module\ble\inc;..\..\..\..\bc_ros\bc_util;..\..\..\..\bc_ros\bc_util\bc_log;..\..\..\..\bc_ros\bc_util\bc_delay;..\..\..\..\bc_ros\bc_config;..\..\..\..\bc_ros\bc_driver\q_device\src;..\..\..\..\bc_ros\bc_driver\q_device\inc;..\..\..\..\bc_ros\bc_driver\bsp\src;..\..\..\..\bc_ros\bc_driver\bsp\inc;..\..\..\..\bc_ros\bc_module\device_info;..\..\..\..\bc_ros\bc_module\strategy_value;..\..\components\ble\peer_manager;..\..\components\ble\ble_services\ble_hids;..\..\components\libraries\fds;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_dis;..\..\..\..\bc_ros\bc_module;..\..\..\..\bc_ros\bc_module\queue;..\..\..\..\bc_ros\bc_rtos;..\..\..\..\bc_ros\bc_module\sem;..\..\..\..\bc_ros\bc_application;..\..\..\..\bc_ros\bc_device\yhm2712;..\..\..\..\bc_ros\bc_module\pmic;..\..\..\..\bc_ros\bc_module\bc_ldo_switch;..\..\..\..\bc_ros\bc_module\rtc;..\..\..\..\bc_ros\bc_device\icm42688;..\..\..\..\bc_ros\bc_module\gsensor;..\..\..\..\bc_ros\bc_module\i2c_bus;..\..\..\..\bc_ros\bc_module\ppg;..\..\..\..\bc_ros\bc_device\hx3605;..\..\..\..\bc_ros\bc_algorithm;..\..\..\..\bc_ros\bc_device\temper\gxt310;..\..\..\..\bc_ros\bc_module\temp;..\..\..\..\bc_ros\bc_module\wtd;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\HR;..\..\..\..\bc_ros\bc_device\gh3228T\alg_params\SPO2;..\..\..\..\bc_ros\bc_device\gh3228T\driver\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_application\inc;..\..\..\..\bc_ros\bc_device\gh3228T\goodix_algo_call\inc;..\..\..\..\bc_ros\bc_device\gh3228T\kernel;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_agc;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_other;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_ecg;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_protocol;..\..\..\..\bc_ros\bc_device\gh3228T\module\gh_soft_adt;..\..\..\..\bc_ros\bc_module\file\LittleFS;..\..\..\..\bc_ros\bc_module\spi_flash;..\..\..\..\bc_ros\bc_module\spi_flash\sfud\inc;..\..\..\..\bc_ros\bc_module\touch_button\q_multi_button;..\..\..\..\bc_ros\bc_module\key;..\..\..\..\bc_ros\bc_module\motor;..\..\..\..\bc_ros\bc_device\sy6103;..\..\..\..\bc_ros\bc_device\da267;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\include;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100;..\..\..\..\bc_ros\bc_device\nfc\st\st25r100\RFAL\source\st25r200;..\..\..\..\bc_ros\bc_module\nfc;..\..\..\..\bc_ros\bc_device\touch_button\IQS7211E;..\..\..\..\bc_ros\bc_module\touch_button;..\..\..\..\bc_ros\bc_module\pdm;..\..\..\..\bc_ros\bc_module\led;..\..\..\..\bc_ros\bc_device\lsm6dsow;..\..\..\..\bc_ros\bc_module\DB;..\..\..\..\bc_ros\bc_module\DB\FAL\inc;..\..\..\..\bc_ros\bc_module\DB\FlashDB\inc;..\..\..\..\bc_ros\bc_module\wifi;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\src;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\celt;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\include;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk\fixed;..\..\..\..\bc_ros\bc_module\opus\opus-1.5.2\silk\float;..\..\..\..\bc_ros\bc_module\DB\FlashDB\src;..\..\..\..\bc_ros\bc_device\Icm426xx;..\..\..\..\bc_ros\bc_device\ic_led\tx1812n5;..\..\..\..\bc_ros\bc_module\led
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20004758 size 0x3be70
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
  group user
    ../../user/src/: main.c test.c user.c
    ../../user/inc/: FreeRTOSConfig.h user_rtos_config.h sdk_config.h
    ../../../../bc_ros/bc_config/: ring_config.h customer.h
  group app
    ../../../../bc_ros/bc_application/: app.c app_package.c app_rtc_handler.c app_ble_handler.c app_pmic_handler.c app_g_sensor_handler.c app_model_handler.c app_cmd_handler.c app_temper_handler.c app_hardware_check.c app_ppg_file_data_handler.c app_key_handler.c app_linear_motor_handler.c app_touch_button_handler.c app_pdm_handler.c app_hardline_tsdb_handler.c app_six_axis_sensor_handler.c
  group bc_moudle
    ../../../../bc_ros/bc_module/: bc_module.c
    ../../../../bc_ros/bc_module/device_info/: bc_device_info.c
    ../../../../bc_ros/bc_module/strategy_value/: bc_strategy_value.c
    ../../../../bc_ros/bc_module/bc_ldo_switch/: bc_ldo_switch.c
    ../../../../bc_ros/bc_module/rtc/: bc_rtc.c
    ../../../../bc_ros/bc_module/i2c_bus/: bc_device_i2c_bus_handler.c
    ../../../../bc_ros/bc_module/wtd/: bc_watchdog.c
    ../../../../bc_ros/bc_module/motor/: bc_linear_motor.c
    ../../../../bc_ros/bc_module/pdm/: bc_pdm.c
    ../../../../bc_ros/bc_module/timer/: bc_timer.c
  group bc_module/pmic
    ../../../../bc_ros/bc_module/pmic/: bc_pmic.c bc_power.c bc_pmic_device_port.c
  group bc_module/g_sensor
    ../../../../bc_ros/bc_module/gsensor/: bc_gsensor.c bc_g_sensor_device_port.c
  group bc_module/temper
    ../../../../bc_ros/bc_module/temp/: bc_temp.c bc_temp_port.c
  group bc_moudle/spi_flash
    ../../../../bc_ros/bc_module/spi_flash/: bc_spi_flash.c bc_spi_flash_port.c
  group bc_module/key
    ../../../../bc_ros/bc_module/key/: bc_key.c
  group bc_module/nfc
    ../../../../bc_ros/bc_module/nfc/: bc_nfc_read_st25r100_port.c
  group bc_module/wifi
    ../../../../bc_ros/bc_module/wifi/: bc_wifi_port.c bc_wifi.c
  group bc_moudle/led
    ../../../../bc_ros/bc_module/led/: bc_led_pwm.c bc_led.c bc_ic_led.c
  group bc_module/touch_button
    ../../../../bc_ros/bc_module/touch_button/: bc_touch_button.c bc_touch_button_device_port.c
  group bc_device/pmic
    ../../../../bc_ros/bc_device/yhm2712/: yhm2712.c
    ../../../../bc_ros/bc_device/sy6103/: sy6103.c
  group bc_device/g_sensor
    ../../../../bc_ros/bc_device/da267/: da267.c
    ../../../../bc_ros/bc_device/icm42688/: icm42688.c
  group bc_device/g_sensor/st/lsm6dso
    ../../../../bc_ros/bc_device/lsm6dsow/: lsm6dso.c lsm6sdo_port.c lsm6dso_reg.c
  group bc_device/temper/gxt310
    ../../../../bc_ros/bc_device/temper/gxt310/: gxt310.c
  group bc_device/ic_led/tx1812n5
    ../../../../bc_ros/bc_device/ic_led/tx1812n5/: tx1812n5.c
  group bc_device/touch_button
    ../../../../bc_ros/bc_device/touch_button/IQS7211E/: IQS7211E.c
  group bc_rtos
    ../../../../bc_ros/bc_module/queue/: bc_queue.c
    ../../../../bc_ros/bc_module/sem/: bc_sem.c
    ../../../../bc_ros/bc_rtos/: bc_rtos.c
  group bc_algorithm
    ../../../../bc_ros/bc_algorithm/: bc_algorithm.lib
  group bc_driver
    ../../../../bc_ros/bc_driver/bsp/src/: bsp.c bsp_rtc.c bsp_sys.c bsp_adc.c bsp_spi2.c bsp_flash.c bsp_i2c0.c bsp_i2c1.c bsp_pwm0.c bsp_pwm1.c bsp_io_input.c bsp_io_output.c bsp_soft__i2c2.c bsp_soft__i2c3.c bsp_soft__i2c4.c bsp_soft__i2c5.c bsp_stacmd.c bsp_watchdog.c bsp_soft__i2c6.c bsp_soft_spi3.c
  group bc_util
    ../../../../bc_ros/bc_util/: bc_util.c crc.c crcLib.c
    ../../../../bc_ros/bc_util/bc_log/: bc_logger.c
    ../../../../bc_ros/bc_util/bc_delay/: bc_delay.c
  group BC_Ble
    ../../../../bc_ros/bc_module/ble/src/: bc_ble.c bc_ble_adv.c bc_ble_dfu.c bc_ble_gap.c bc_ble_gatt.c bc_ble_hids_service.c bc_ble_info_service.c bc_ble_modu_interface.c bc_ble_tx.c bc_file_transfer.c
  group LittleFS
    ../../../../bc_ros/bc_module/file/LittleFS/: lfs.c lfs_util.c lfs_port.c
  group SFUD
    ../../../../bc_ros/bc_module/spi_flash/sfud/src/: sfud.c sfud_sfdp.c
    ../../../../bc_ros/bc_module/spi_flash/sfud/port/: sfud_port.c
  group FAL
    ../../../../bc_ros/bc_module/DB/FAL/src/: fal.c fal_flash.c fal_partition.c
    ../../../../bc_ros/bc_module/DB/: bc_flash_port.c
  group FlashDB
    ../../../../bc_ros/bc_module/DB/FlashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_utils.c fdb_tsdb.c
  group Q_Multi_Button
    ../../../../bc_ros/bc_module/touch_button/q_multi_button/: q_multi_button.c
  group Q_Device
    ../../../../bc_ros/bc_driver/q_device/src/: q_device.c q_init.c
  group freertos
    ../../external/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../external/freertos/source/portable/MemMang/: heap_4.c
    ../../external/freertos/portable/ARM/nrf52/: port.c
    ../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group UTF8/UTF16 converter
    ../../external/utf_converter/: utf.c
  group nRF_BLE
    ../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../components/ble/ble_advertising/: ble_advertising.c
    ../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../components/ble/ble_services/ble_hids/: ble_hids.c
    ../../components/ble/peer_manager/: pm_buffer.c security_dispatcher.c security_manager.c peer_manager.c peer_manager_handler.c peer_id.c peer_database.c peer_data_storage.c id_manager.c gatts_cache_manager.c gatt_cache_manager.c
  group nRF_DFU
    ../../components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_bonded.c ble_dfu_unbonded.c
  group nRF_Drivers
    ../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c nrf_drv_twi.c nrf_drv_spi.c
    ../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c nrfx_twim.c nrfx_twis.c nrfx_rtc.c nrfx_twi.c nrfx_saadc.c nrfx_wdt.c nrfx_pwm.c nrfx_power.c nrfx_pdm.c nrfx_nfct.c nrfx_spi.c nrfx_spim.c nrfx_timer.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../modules/nrfx/soc/: nrfx_atomic.c
  group nRF_Libraries
    ../../components/libraries/button/: app_button.c
    ../../components/libraries/scheduler/: app_scheduler.c
    ../../components/libraries/hardfault/: hardfault_implementation.c
    ../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/sortlist/: nrf_sortlist.c
    ../../components/libraries/uart/: app_uart_fifo.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/libraries/timer/: app_timer_freertos.c
    ../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../components/libraries/fds/: fds.c
  group nRF_SVC
    ../../components/libraries/bootloader/dfu/: nrf_dfu_svci.c
  group nRF_Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
software components: CMSIS:CORE 5.4.0, Device:Startup 8.35.0
